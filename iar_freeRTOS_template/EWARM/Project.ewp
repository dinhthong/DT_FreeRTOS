# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx
  ICCARM.CCIncludePath2: ..; C:\Users\Admin\Downloads\read_RC_rtos\Libraries\CMSIS\Device\ST\STM32F4xx\Include; C:\Users\Admin\Downloads\read_RC_rtos\Libraries\STM32F4xx_StdPeriph_Driver\inc; ; C:\Users\Admin\Downloads\read_RC_rtos\FreeRTOS\include; C:\Users\Admin\Downloads\read_RC_rtos\FreeRTOS\portable\IAR\ARM_CM4F; C:\Users\Admin\Downloads\read_RC_rtos\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: FreeRTOS.hex
  ILINK.IlinkOutputFile: FreeRTOS.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f407xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkOutputFile: ext.out
  group EWARM
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_3.c
    ../FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ../: main.c stm32f4xx_it.c system_stm32f4xx.c
